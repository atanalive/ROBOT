# Keil uVision project autocar(alive).uvprojx, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: automatic car(ALIVE) +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\ACTION\MOVING;..\ACTION\TASK;..\HARDWARE\TIM;..\CONTROL\PID;..\HARDWARE\ENCODER;..\ACTION\FSM;..\HARDWARE\HC_SR04;..\ACTION\MOTOR;..\CONTROL\CONTROL;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050\USMART;..\HARDWARE\MG995;..\ACTION\DEBUG;..\HARDWARE\VL53L0X\core\inc;..\HARDWARE\VL53L0X\demo;..\HARDWARE\VL53L0X\platform\inc;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\LED;..\ACTION\GRAB;..\CONTROL\VISION;..\CONTROL\FEEDBACK;..\ACTION\PATH;..\HARDWARE\DIAL_SWITCH;..\HARDWARE\USART3;..\HARDWARE\TCRT5000;..\HARDWARE\USART2;..\USMART;..\HARDWARE\UART4
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/HC_SR04/: hc_sr04.c
    ../HARDWARE/MPU6050/: mpu6050.c mpu_iic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
    ../HARDWARE/MG995/: mg995.c
    ../HARDWARE/VL53L0X/demo/: vl53l0x.c vl53l0x_gen.c
    ../HARDWARE/LED/: led.c
    ../ACTION/MOTOR/: motor.c
    ../HARDWARE/DIAL_SWITCH/: dial_switch.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TCRT5000/: tcrt5000.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/UART4/: uart4.c
  group ACTION
    ../ACTION/MOVING/: moving.c
    ../ACTION/TASK/: task.c
    ../ACTION/FSM/: fsm.c
    ../ACTION/DEBUG/: debug.c
    ../ACTION/GRAB/: grab.c
    ../ACTION/PATH/: path.c
  group CONTROL
    ../CONTROL/PID/: pid.c
    ../CONTROL/CONTROL/: control.c
    ../CONTROL/VISION/: vision.c
    ../CONTROL/FEEDBACK/: feedback.c
  group READ
    ../READ/: ALIVE.txt control_to_visual(AtanAlive).txt
  group USMART
    ../HARDWARE/MPU6050/USMART/: usmart_to_pc.c
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group 53L0X
    ../HARDWARE/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../HARDWARE/VL53L0X/platform/src/: vl53l0x_platform.c vl53l0x_i2c.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
